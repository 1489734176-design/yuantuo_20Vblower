# Keil uVision project MM32SPIN0230_Demo.uvprojx, settings and files
target MM32SPIN0230 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32SPIN0230B1NV MindMotion
  pack: MindMotion.MM32SPIN0230_DFP.1.1.2
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SPIN0230_DEMO +hex
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_5V
  c include: D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\MM32SPIN0230\Include;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\MM32SPIN0230\HAL_Lib\inc;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\DRIVE\inc;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\SYSTEM\inc;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\USER\inc;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\M1_CONTROL\inc;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\MM_MCLIB\inc;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\MM_MCLIB\inc;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\MY_MC;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\MOTOR_CONTROL;D:\mym\NXN\3.yuantuo\V7_baofengji\source code\NX32F002-V1.00-lib-release\MC_CORE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group USER
    D:/mym/NXN/3.yuantuo/V7_baofengji/source code/NX32F002-V1.00-lib-release/USER/: main.c board.c mm32_it.c user_control.c led.c flash_data_save.c Bat_com.c
    D:/mym/NXN/3.yuantuo/V7_baofengji/source code/NX32F002-V1.00-lib-release/USER/inc/: parameter.h
  group SYSTEM
    D:/mym/NXN/3.yuantuo/V7_baofengji/source code/NX32F002-V1.00-lib-release/SYSTEM/: systick.c
  group DRIVE
    D:/mym/NXN/3.yuantuo/V7_baofengji/source code/NX32F002-V1.00-lib-release/DRIVE/: drv_adc.c drv_comp.c drv_div.c drv_iwdg.c drv_led.c drv_opamp.c drv_pwm.c
  group HAL_LIB
    D:/mym/NXN/3.yuantuo/V7_baofengji/source code/NX32F002-V1.00-lib-release/MM32SPIN0230/HAL_Lib/src/: hal_adc.c hal_comp.c hal_dbg.c hal_dma.c hal_exti.c hal_flash.c hal_gpio.c hal_hwdiv.c hal_iwdg.c hal_misc.c hal_opamp.c hal_pwr.c hal_rcc.c hal_syscfg.c hal_tim.c hal_uid.c hal_usart.c
  group Startup
    D:/mym/NXN/3.yuantuo/V7_baofengji/source code/NX32F002-V1.00-lib-release/MM32SPIN0230/Source/: system_mm32spin0230.c
    D:/mym/NXN/3.yuantuo/V7_baofengji/source code/NX32F002-V1.00-lib-release/MM32SPIN0230/Source/KEIL_StartAsm/: startup_mm32spin0230_keil.s
  group MOTOR_CONTROL
    D:/mym/NXN/3.yuantuo/V7_baofengji/source code/NX32F002-V1.00-lib-release/MOTOR_CONTROL/: motor_control.c motor_config.h
  group MC_CORE
    D:/mym/NXN/3.yuantuo/V7_baofengji/source code/NX32F002-V1.00-lib-release/MC_CORE/: 002_mc_core_HS-V1_01.lib
software components: CMSIS:CORE 5.6.0
